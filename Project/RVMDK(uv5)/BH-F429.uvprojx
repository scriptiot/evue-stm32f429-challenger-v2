# Keil uVision project BH-F429.uvprojx, settings and files
target USB_FLASH (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: evue +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_USB_OTG_HS,USE_EMBEDDED_PHY,LV_CONF_INCLUDE_SIMPLE,LV_LVGL_H_INCLUDE_SIMPLE,CONFIG_EVM_ECMA_OBJECT,CONFIG_EVM_ECMA_ARRAY,CONFIG_EVM_ECMA_NUMBER,CONFIG_EVM_ECMA_STRING,CONFIG_EVM_ECMA_STRING,CONFIG_EVM_ECMA_TIMEOUT
  c misc: --gnu
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\USER;..\..\USER\app;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\USER\Bsp;..\..\lvgl;..\..\modules\ecma\inc;..\..\modules\hml;..\..\modules\hml\frameworks;..\..\modules\hml\lvgl\hml_element;..\..\modules\hml\lvgl\lv_lib_png;..\..\libevm\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../USER/: main.c stm32f4xx_it.c evm_main.c lvgl_main.c lv_conf.h
    ../../modules/hml/frameworks/: app_config.h
  group BSP
    ../../USER/Bsp/led/: bsp_led.c
    ../../USER/Bsp/usart/: bsp_debug_usart.c
    ../../USER/Bsp/flash/: bsp_spi_flash.c
    ../../USER/Bsp/FATFS/: diskio.c ff.c
    ../../USER/Bsp/FATFS/option/: unicode.c
    ../../USER/Bsp/key/: bsp_key.c
    ../../USER/Bsp/lcd/: bsp_lcd.c
    ../../USER/Bsp/sdram/: bsp_sdram.c
    ../../USER/Bsp/font/: fonts.c
    ../../USER/Bsp/systick/: bsp_SysTick.c
    ../../USER/Bsp/touch/: bsp_i2c_touch.c gt9xx.c
  group USB Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB Device
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group App
    ../../USER/app/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group lv_core
    ../../lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group lv_draw
    ../../lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lv_font
    ../../lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c
  group lv_hal
    ../../lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ../../lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lv_themes
    ../../lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c
  group lv_widgets
    ../../lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group ecma
    ../../modules/ecma/src/: ecma.c ecma_array.c ecma_number.c ecma_object.c ecma_string.c ecma_timeout.c
  group hml
    ../../modules/hml/frameworks/: js_app.c js_fwk_module.c js_page_state.c js_page_state_machine.c js_router.c
    ../../modules/hml/lvgl/: hml_lvgl_module.c hml_lvgl_utils.c hml_style.c
    ../../modules/hml/lvgl/hml_element/: hml_base.c hml_chart.c hml_div.c hml_image.c hml_image_animator.c hml_input.c hml_list.c hml_listitem.c hml_marquee.c hml_picker_view.c hml_progress.c hml_slider.c hml_stack.c hml_swiper.c hml_switch.c hml_text.c
    ../../modules/hml/lvgl/lv_lib_png/: lodepng.c lv_png.c
    ../../modules/hml/: hml_module.c
    ../../modules/hml/lvgl/widgets/: lv_marquee.c
  group libevue
    ../../libevm/lib/evue/keil/: libevue.lib
  group malloc
    ../../USER/: malloc.c
